FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://am335x-pocketbeagle.dts.patch"
SRC_URI += "file://logging.cfg"
